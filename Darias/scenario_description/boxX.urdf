Commit message: add hanoiTower task for PR2

File: Darias/scenario_description/boxX.urdf (robot description, URDF)
Before this commit: robot boxX, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.12 0.12 0.14; visual box size=0.12 0.12 0.14
